Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: cep3-6408-2350.ifc
Time: 2026-03-17T14:30:45
Author: faimard
Organization: BIMDeX
Written by: BIMDeX 25.0.0.1
Made in: BIMDeX

# IfcProject, Default Project
Description: Description of Default Project; Phase: Project Status
PTC_Identity Data - TITRE: CUVE A RECUPERATION D'EAU DE PLUIE; SOUS_TITRE: Gros volume de 17 à 60m³; NOM_PROJET: AQUAFILTRE XL PRV; DESSINATEUR: AE; VERIFICATEUR: BPM; REFERENCE: CEP3-2350; REFERENCE_HYDREAL: CREP50-PRV; TOLERANCES_GENERALES: ±1mm sauf indications; DATE: 03/12/2025; LANGUE: FR; NUMPLAN: B4300.26.011; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PROJET: AQUAFILTRE XL PRV; PTC_MODIFIED: yes; PTC_WM_REVISION: A; PTC_WM_ITERATION: 2; PTC_WM_VERSION: A.2; PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_LOCATION: /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640; PTC_WM_CREATED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_CREATED_ON: 12-Nov-25 11:40:34 AM; PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_MODIFIED_ON: 17-Mar-26 02:12:48 PM; PTC_ORGANIZATION_ID: SIMOP; CODE: -; PDMREV: A.2+; PDMRL: En cours de traitement; PROI_REVISION: A; PROI_VERSION: 2+; PROI_RELEASE: En cours de traitement; MASSE_KG: 1726.72; VOLUME: 795687000; AIRE: 347.726; PTC_WM_NAME: cep3-6408-gen.asm_INST8; PTC_WM_NUMBER: CEP3-6408-2350.ASM; TITRE_SIMOP: CUVE A RECUPERATION D'EAU DE PLUIE - TAILLE 50; REFERENCE_SIMOP: CEP3/6408/2350; PTC_COMMON_NAME: cep3-6408-gen.asm_INST8

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Storey
In: Default Building
Description: Description of Default Building Storey

# IfcBuildingElementProxy: General (36)
In: Default Storey
PTC_Identity Data - PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_ORGANIZATION_ID: SIMOP; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement
Name | TITRE | REFERENCE | PTC_MATERIAL_NAME = PTC_REPORTED_MATERIAL | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION | PTC_WM_VERSION | PTC_WM_LOCATION | PTC_WM_CREATED_BY | PTC_WM_CREATED_ON | PTC_WM_MODIFIED_BY | PTC_WM_MODIFIED_ON | MASSE_KG | VOLUME (m3) | AIRE | PTC_MODIFIED | PDMREV | PROI_VERSION | PTC_WM_NAME | PTC_WM_NUMBER | PTC_COMMON_NAME | PTC_MASTER_MATERIAL
CS578-VIR-D23-EP7-6_5M_1 | virole Ø2300 EP 7 | CS578 | PRV_VIROLE_DV23 | B | 11 | B.11 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Viroles | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 13-Mar-26 11:54:08 AM | 1525.52 | 699781000 | 184.097 | yes | B.11+ | 11+ | CS578-VIR-D23-EP7-6_5M.PRT | CS578-VIR-D23-EP7-6_5M.PRT | CS578-VIR-D23-EP7-6_5M.PRT | PRV_VIROLE_DV23 | PTC_Identity Data - DESSINATEUR: BEA; LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 2.10274; PROI_MODIFIED: 1; TULIPAGE: 1; NUMPLAN: A2300.20.125; Instance Property - IN_D_9: 12686; IN_D_28: 500; IN_D_27: -2000
2 x SST-CS242-FB2300-RTM | FOND BOMBE 2300 | SST-CS242 | PRV | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | Benoît AUDE (baude: simop) | 12-Jul-24 11:05:21 AM | Fabrice AIMARD (faimard: simop) | 09-Mar-26 05:50:22 PM | 61.6436 | 39014900 | 7.82119 | yes | A.7+ | 7+ | A2300.22.066 | SST-CS242-FB2300-RTM.PRT | A2300.22.066 | PRV | PTC_Identity Data - DESSINATEUR: BEA; LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: -; PROGRAM: no; NOMBRE: 0; NUMPLAN: A2300.22.066; SOUS_TITRE: RTM; NOM_PROJET: -; VERIFICATEUR: TERRE ENTIERE; TOLERANCES_GENERALES: ±1%; DATE: 17/06/2022; MC_ERRORS: 1
SST-CS750-TH-D750-PRV_1 | TROU D'HOMME PRV Ø750 | SST-CS750 | PRV | K | 4 | K.4 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme | Benoît AUDE (baude: simop) | 07-Feb-23 09:35:19 AM | Fabrice AIMARD (faimard: simop) | 12-Mar-26 06:00:00 PM | 6.49892 | 4113240 | 1.04231 | yes | K.4+ | 4+ | SST-CS750-TH-D750-PRV | SST-CS750-TH-D750-PRV.PRT | SST-CS750-TH-D750-PRV | PRV | PTC_Identity Data - DESSINATEUR: BEA; LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: SST-CS-263-TUBE-D750; PROGRAM: no; NOMBRE: 0; NUMPLAN: A2100.19.181; SOUS_TITRE: LONGUEUR 1 M; VERIFICATEUR: EB; TOLERANCES_GENERALES: ±5mm; DATE: 19/09/2019; MASSE_GR: 6498.92; MFG_WP_MATERIAL: PRV
JOINT-PLAT-KTHSF_750 | JOINT NITRILE D10/12 Rlx30M | JOC10/12 | NITRILE | B | 2 | B.2 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHSF DIAM | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.337124 | 229336 | 0.114668 | no | B.2 | 2 | joint-plat-kthsf_750.prt | JOINT-PLAT-KTHSF_750.PRT | joint-plat-kthsf_750.prt | NITRILE | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; PROGRAM: no; NOMBRE: 0; MC_ERRORS: 1; IFC_EXPORT_TYPE: IsSelectedForExport_
CU371-COLLET-D600 | CORPS COLLET D.600 BLAISE | CU371 | PEHD3850 | B | 1 | B.1 | /Bibliothèques/Eléments Standards Internes/Accès voiries/Collets | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 1.6581 | 1767700 | 0.554874 | no | B.1 | 1 | CU371-COLLET-D600.prt | CU371-COLLET-D600.PRT |  | PEHD3850 | PTC_Identity Data - IFC_EXPORT_TYPE: IsSelectedForExport_
JOC10_12-JOINT-NITRILE-KTHSF750 | JOINT TORIQUE DIAM.12 L1520 | AD203-1 | NITRILE | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Etanchéité/Joint-kthsf | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.260424 | 177159 | 0.0708638 | no | B.2 | 2 | joc10_12-joint-nitrile-kthsf750.prt | JOC10_12-JOINT-NITRILE-KTHSF750.PRT | joc10_12-joint-nitrile-kthsf750.prt | NITRILE | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; PROGRAM: no; NOMBRE: 0; MC_ERRORS: 1; IFC_EXPORT_TYPE: IsSelectedForExport_
CU325-TAMPON-D600 | CORPS TAMPON A VISSER D600 | CU325 | PEHD3850 | D | 3 | D.3 | /Bibliothèques/Eléments Standards Internes/Accès voiries/Couvercle-Tampons/PE | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 7.02098 | 7485060 | 1.45966 | no | D.3 | 3 | cu325-tampon-d600.prt | CU325-TAMPON-D600.PRT |  | PEHD3850 | PTC_Identity Data - DESSINATEUR: G.THEBAULT; LANGUE: FR; NUMPLAN: 21-95-044; SOUS_TITRE: POUR SEPARATEUR HYDROCARBURES; VERIFICATEUR: Y.LEPRIEUR; DATE: 15/05/95; MC_ERRORS: 2; MFG_WP_MATERIAL: PEHD3850; IFC_EXPORT_TYPE: IsSelectedForExport_
8 x FCV051-RIVET-AGRAPHE-4_8-30 | RIVET AGRAPHE 4.8x30 | FCV051 | 304 | B | 1 | B.1 | /Bibliothèques/Eléments Standards/Eléments de fixations/Rivets | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.00737099 | 933.036 | 0.000499301 | no | B.1 | 1 | fcv051-rivet-agraphe-4_8-30.prt | FCV051-RIVET-AGRAPHE-4_8-30.PRT | fcv051-rivet-agraphe-4_8-30.prt | 304 | PTC_Identity Data - DESSINATEUR: BIBLIOTHECAIRE; VERIFICATEUR: AUGUSTYN; IFC_EXPORT_TYPE: IsSelectedForExport_; MASSE: 0.0001137; MATIERE: AGS; DATE_DESS: -; DESIGNATION: -; PROTECTION: -; NGPAO: -; ASPECT: -; ETSURF: -; EFFECTUE_PAR: -; UNITE: UNITAIRE; VISSERIE: yes; OLD_BASE: yes
PATTE-CADENASSAGE-TH600 | EQUERRE DE CADENASSAGE | AC133 | ACIER | A | 1 | A.1 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 0.064154 | 8194.41 |  | no | A.1 | 1 | patte-cadenassage-th600.prt | PATTE-CADENASSAGE-TH600.PRT | patte-cadenassage-th600.prt | ACIER | PTC_Identity Data - DESSINATEUR: M.LEDAN; LANGUE: Fr; FOURNISSEUR: -; PRIX: 0; NOM: PATTE-CADENASSAGE-TH600; PROGRAM: no; NOMBRE: 0; VERIFICATEUR: G.THEBAULT; TOLERANCES_GENERALES: ±0,2mm sauf indications; DATE: 17/05/13; MASSE_GR: 64.154
PATTE-CADENASSAGE-CU325 | PATTE DE CADENASSAGE | AC132 | ACIER | B | 2 | B.2 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Benoît AUDE (baude: simop) | 18-Jul-25 04:13:00 PM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 0.0904886 | 11558.1 | 0.00470532 | no | B.2 | 2 | patte-cadenassage-cu325.prt | PATTE-CADENASSAGE-CU325.PRT | patte-cadenassage-cu325.prt | ACIER | PTC_Identity Data - DESSINATEUR: M.LEDAN; LANGUE: Fr; FOURNISSEUR: -; PRIX: 0; NOM: PATTE-CADENASSAGE-CU325; PROGRAM: no; NOMBRE: 0; NUMPLAN: B4300.13.142; SOUS_TITRE: Tampon à visser Ø600; VERIFICATEUR: G.THEBAULT; TOLERANCES_GENERALES: ±0,2mm sauf indications; DATE: 17/05/13; MASSE_GR: 90.4886
ANNEAU_CADENAS | CADENAS D'ARTILLERIE LAITON | AC011 |  | A | 1 | A.1 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 0.0529797 | 33112.3 |  | no | A.1 | 1 | anneau_cadenas.prt | ANNEAU_CADENAS.PRT |  | PTC_SYSTEM_MTRL_PROPS | PTC_Identity Data - MASSE: 0.0000529797; MATIERE: Polyester; DESSINE_PAR: --; SURFACE: 90604.4; DESIGNATION_2: --
3 x VIS_AUTO_TARAUDEUSE | VIS AUTOPERC TETE ENROB | BV7007 | ACIER | A | 2 | A.2 | /Bibliothèques/Eléments Standards/Eléments de fixations/Vis | Benoît AUDE (baude: simop) | 21-Jan-13 11:44:29 AM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 0.001 | 1080.8 |  | no | A.2 | 2 | vis_auto_taraudeuse.prt | VIS_AUTO_TARAUDEUSE.PRT | vis_auto_taraudeuse.prt | ACIER
2 x BV410-1-TIRE-FOND-10X40 | TIRE FOND 10x40 TH CR VP/PLAT | BV410-1 | 304 | A | 3 | A.3 | /Bibliothèques/Eléments Standards/Eléments de fixations/Vis | Benoît AUDE (baude: simop) | 21-Jan-13 10:30:06 AM | Benoît AUDE (baude: simop) | 07-Feb-19 11:28:27 AM | 0.0222085 | 2811.2 | 0.00120145 | no | A.3 | 3 | BV410-1-TIRE-FOND-10X40.PRT | BV410-1-TIRE-FOND-10X40.PRT | BV410-1-TIRE-FOND-10X40.PRT | 304 | PTC_Identity Data - MASSE: 0.0000222085; MATIERE: Polyester; DESIGNATION: 85.05.274; DESSINE_PAR: JFL; SURFACE: 90604.4; VERIF_PAR_CONCEPTION: YL; VERIF_PAR_BE: YL
TU160-PVC-300 | TU160 PVC | TU160 | PVC | A | 1 | A.1 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 0.588994 | 417726 |  | no | A.1 | 1 | tu160-pvc-350.prt | TU160-PVC-300.PRT | tu160-pvc-350.prt | PVC | PTC_Identity Data - MASSE: 0.000588994; MATIERE: Polyester; DESSINE_PAR: ghg; SURFACE: 90604.4
JS160 | CRS JOINT SIMOP D160 QUALITE HYDRO | JS160 | NITRILE | A | 4 | A.4 | /Bibliothèques/Eléments Standards Internes/Etanchéité/Joint-JS | Fabrice AIMARD (faimard: simop) | 17-Jul-12 04:31:41 PM | Baptiste LEFRANC (Supprimé) | 30-Jul-21 03:15:32 PM | 0.0679346 | 46214 | 0.0332967 | no | A.4 | 4 | js160.prt | JS160.PRT | js160.prt | NITRILE | PTC_Identity Data - MFG_WP_MATERIAL: NITRILE; MASSE: 0.0000679346
AHM106_MANCHON-D160-PRESSION | MANCHON D160 PVC PRESSION | AHM106 | PVC | A | 6 | A.6 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Pression/Manchon | Fabrice AIMARD (faimard: simop) | 17-Jul-12 03:45:21 PM | Benoît AUDE (baude: simop) | 17-Jun-21 03:21:43 PM | 1.40413 | 995836 | 0.10448 | no | A.6 | 6 | AHM106_MANCHON-D160-PRESSION.PRT | AHM106_MANCHON-D160-PRESSION.PRT | AHM106_MANCHON-D160-PRESSION.PRT | PVC | PTC_Identity Data - NOM: AHM106_MANCHON-D160-PRESSION; PTC_PP_MODIFIED_ON: 16-May-11 10:08:50 AM; PTC_PP_VERSION: -.1; PTC_PP_REVISION: -; PTC_PP_ITERATION: 1; PTC_PP_RELEASE_STATE: En cours; PTC_PP_MODIFIED_BY: Maxime LEDAN; PTC_PP_LOCATION: /Catalog/Parts/Travail ProENGINEER/Eléments-Canalisations/PVC-Ecoulement/Manchon; PTC_PP_CREATED_BY: Maxime LEDAN; PTC_PP_OWNER: Maxime LEDAN; PTC_PP_CREATED_ON: 16-May-11 10:08:49 AM
JS100_1 | CRS JOINT SIMOP D100 QUALITE HYDRO | JS100 | NITRILE | J | 1 | J.1 | /Bibliothèques/Eléments Standards Internes/Etanchéité/Joint-JS | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.0453998 | 30884.2 | 0.0212042 | no | J.1 | 1 | js100.prt | JS100.PRT | js100.prt | NITRILE | PTC_Identity Data - MC_ERRORS: 3; IFC_EXPORT_TYPE: IsSelectedForExport_
JS063 | Joint Simop Ø63 | JS063 | NBR | F | 4 | F.4 | /Bibliothèques/Eléments Standards Internes/Etanchéité/Joint-JS | Fabrice AIMARD (faimard: simop) | 24-Sep-15 02:16:08 PM | Maxime LEDAN (mledan: simop) | 26-Oct-17 06:33:37 PM | 0.029059 | 23247.2 | 0.00747603 | no | F.4 | 4 | js063.prt | JS063.PRT | js063.prt | NBR
TU063_TUBE-DN63-ECOULEMENT_1 | TUBE PVC DIAM.43,6/50 | TU050 | PVC | A | 0 | A.0 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Fabrice AIMARD (faimard: simop) | 09-Nov-17 02:06:41 PM | Fabrice AIMARD (faimard: simop) | 23-Nov-17 03:11:18 PM | 0.0802991 | 56548.7 | 0.0388301 | no | A.0 | 0 | tu063_tube-dn63-ecoulement.prt | TU063_TUBE-DN63-ECOULEMENT.PRT | tu063_tube-dn63-ecoulement.prt | PVC | PTC_Identity Data - DESSINATEUR: M.LEDAN; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 0.000255176; VERIFICATEUR: BEA; DATE: 08/04/2015; MC_ERRORS: 1; LONGUEUR: 100
TU100-NF_TUBE_DN100_EVAC_NF_1 | TUBE PVC DIAM.96,5/100 NF | TU100-NF | PVC | A | 6 | A.6 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Benoît AUDE (baude: simop) | 02-Dec-15 11:45:43 AM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.128903 | 91420.3 | 0.0627753 | no | A.6 | 6 | TU100-NF_TUBE_DN100_EVAC_NF.prt | TU100-NF_TUBE_DN100_EVAC_NF.PRT | TU100-NF_TUBE_DN100_EVAC_NF.prt | PVC | PTC_Identity Data - DESSINATEUR: BEA; LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 0.000693978; IFC_EXPORT_TYPE: IsSelectedForExport_
PLANCHER-TH600-2300 | PLANCHER - SUPPORT PANIER AQUAFILTRE DN160 | SST-CS239 | ACIER | A | 1 | A.1 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 04-Jun-13 10:10:36 AM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 6.40658 | 818314 |  | no | A.1 | 1 | plancher-th600-2300.prt | PLANCHER-TH600-2300.PRT | plancher-th600-2300.prt | ACIER | PTC_Identity Data - FOURNISSEUR: -; PRIX: 0; NOM: PLANCHER-TH600-2300; PROGRAM: no; NOMBRE: 0; MASSE_GR: 6406.58
TU160-PVC-800_1 | TUBE PVC | TU160 | PVC | A | 1 | A.1 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Fabrice AIMARD (faimard: simop) | 05-Feb-26 09:48:37 AM | 1.83403 | 1300730 |  | no | A.1 | 1 | tu160-pvc-800.prt | TU160-PVC-800.PRT | tu160-pvc-800.prt | PVC | PTC_Identity Data - MASSE: 0.00183403; MATIERE: Polyester; DESSINE_PAR: ghg; SURFACE: 90604.4
UNION-D32-1P-F-F |  | AD199 | PVC | A | 6 | A.6 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Pression/Raccord | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Benoît AUDE (baude: simop) | 04-Sep-20 02:58:22 PM | 0.110289 | 77668.4 | 0.0208284 | no | A.6 | 6 | AD199 | UNION-D32-1P-F-F.PRT | AD199 | PVC | PTC_Identity Data - MC_ERRORS: 1; MASSE: 0.000110289; MATIERE: Polyester; DESSINE_PAR: ghg; SURFACE: 90604.4
TU032P-150 |  |  |  | A | 2 | A.2 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/AQUAFILT | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | Maxime LEDAN (mledan: simop) | 17-Mar-14 03:38:54 PM |  | 45439.2 |  | no | A.2 | 2 | tu032p-150.prt | TU032P-150.PRT | tu032p-150.prt | PTC_SYSTEM_MTRL_PROPS | PTC_Identity Data - MASSE: 0.0000727027; MATIERE: Polyester; DESSINE_PAR: ghg; SURFACE: 90604.4
COUDE-90-PVC-U-DN25-FF |  |  |  | A | 1 | A.1 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Pression/Coude | Maxime LEDAN (mledan: simop) | 17-Mar-14 03:38:47 PM | Maxime LEDAN (mledan: simop) | 19-Mar-14 10:17:40 AM |  | 29302.2 |  | no | A.1 | 1 | coude-dn32-ff-p.prt_INST4 | COUDE-90-PVC-U-DN25-FF.PRT | coude-dn32-ff-p.prt_INST4 | PTC_SYSTEM_MTRL_PROPS | PTC_Identity Data - MASSE: 0.0000468835; MATIERE: Polyester; DESSINE_PAR: --; SURFACE: 90604.4; DESIGNATION_2: --

# IfcElementAssembly: General (4)
In: Default Storey
PTC_Identity Data - PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_ORGANIZATION_ID: SIMOP; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement
Name | TITRE | REFERENCE | NUMPLAN | PTC_MODIFIED | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION | PTC_WM_VERSION | PTC_WM_LOCATION | PTC_WM_CREATED_BY | PTC_WM_CREATED_ON | PTC_WM_MODIFIED_ON | PDMREV | PROI_VERSION | MASSE_KG | VOLUME | PTC_WM_NAME = PTC_COMMON_NAME | PTC_WM_NUMBER
KTHS750-CEP3 | KIT TROU D'HOMME SIMPLIFIE POUR CEP3 | KTHS750-CEP3 | B4300.26.010 | yes | A | 0 | A.0 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHS 750 | Fabrice AIMARD (faimard: simop) | 29-Oct-25 03:42:36 PM | 17-Mar-26 02:12:48 PM | A.0+ | 0 | 24.8632 | 16321900 | kths750-cep3.asm | KTHS750-CEP3.ASM | PTC_Identity Data - NOM_PROJET: AQUAFILTRE XL PRV; DESSINATEUR: AE; VERIFICATEUR: BPM; TOLERANCES_GENERALES: ±1 mm; DATE: 02/12/2025; LANGUE: Fr; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PROJET: CEP3; CODE: -; AIRE: 7.336
KTHSF750-KIT-FERMETURE-R | KIT FERMETURE REHAUSSABLE THS Ø 750 | KTHSF750R | A2100.19.171 | no | C | 3 | C.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHSF DIAM | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | 20-Jan-26 10:29:57 AM | C.3 | 3 | 9.3356 | 9666720 | A2100-19-171-KTHSF750.ASM | KTHSF750-KIT-FERMETURE-R.ASM | PTC_Identity Data - DESSINATEUR: BEA; VERIFICATEUR: SDLRB; DATE: 30/07/2019; LANGUE: FR; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; CODE: -; AIRE: 4.22259; SOUS_TITRE: POUR TROU D'HOMME PRV Ø 750 SIMPLIFIE; IFC_EXPORT_TYPE: IsSelectedForExport_
SIPHON-COUDE | SIPHON COUDE | KSCEP3 | B4300.13.149 | yes | A | 4 | A.4 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/CEP3-640 | Maxime LEDAN (mledan: simop) | 20-Mar-13 02:14:13 PM | 13-Mar-26 11:54:08 AM | A.4+ | 4+ | 6.82643 | 1300730 | siphon-coude.asm | SIPHON-COUDE.ASM
KASP2-CEP3-AQUA-2300 | KIT ASPIRATION | KASP2 | - | yes | A | 2 | A.2 | /Produits/Produits R et D/Eaux pluviales/Récupération des eaux de pluie/AQUAFILT | Maxime LEDAN (mledan: simop) | 03-Jun-13 12:22:01 PM | 13-Mar-26 11:54:08 AM | A.2+ | 2+ | 5.58803 | 3518050 | kasp2-cep3-aqua-2300.asm | KASP2-CEP3-AQUA-2300.ASM
