Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: cep3-6406-2320.ifc
Time: 2025-09-19T12:39:30
Author: faimard
Organization: BIMDeX
Written by: BIMDeX 25.0.0.1
Made in: BIMDeX

# IfcProject, Default Project
Description: Description of Default Project; Phase: Project Status

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Storey
In: Default Building
Description: Description of Default Building Storey
