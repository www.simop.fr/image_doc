Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: sg3-6632-90.ifc
Time: 2026-02-16T15:17:15
Author: faimard
Organization: BIMDeX
Written by: BIMDeX 25.0.0.1
Made in: BIMDeX

# IfcProject, Default Project
Description: Description of Default Project; Phase: Project Status
PTC_Identity Data - TITRE: Séparateur de graisses PRV; TITRE_HYDREAL: SG3 Generique; SOUS_TITRE: Débourbeur V100 - Taille 90; NOM_PROJET: -; DESSINATEUR: AE; VERIFICATEUR: BPM; REFERENCE: SG3/6632/23090/FBRTM; REFERENCE_HYDREAL: -; TOLERANCES_GENERALES: ±1mm sauf indications; DATE: 11/02/2026; LANGUE: Fr; NUMPLAN: B4300.26.029; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PROJET: -; PTC_MODIFIED: yes; PTC_WM_REVISION: A; PTC_WM_ITERATION: 0; PTC_WM_VERSION: A.0; PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_CREATED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_CREATED_ON: 16-Feb-26 11:54:49 AM; PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_MODIFIED_ON: 16-Feb-26 12:44:13 PM; PTC_ORGANIZATION_ID: SIMOP; CODE: -; PDMREV: A.0+; PDMRL: En cours de traitement; PROI_REVISION: A; PROI_VERSION: 0+; PROI_RELEASE: En cours de traitement; MASSE_KG: 1315.27; VOLUME: 605728000; AIRE: 191.153; PTC_WM_NAME: sg3_6632_gen.asm_INST5; PTC_WM_NUMBER: SG3-6632-90.ASM; TITRE_SIMOP: Séparateur de graisses PRV - Débourbeur V100 - Taille 90; REFERENCE_SIMOP: SG3/6632/23090/FBRTM; PTC_COMMON_NAME: sg3_6632_gen.asm_INST5

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Storey
In: Default Building
Description: Description of Default Building Storey

# IfcBuildingElementProxy: General (10)
In: Default Storey
PTC_Identity Data - PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_ORGANIZATION_ID: SIMOP; PTC_MODIFIED: no; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement
Name | TITRE | REFERENCE | DESSINATEUR | PTC_MATERIAL_NAME = PTC_MASTER_MATERIAL = PTC_REPORTED_MATERIAL | LANGUE | FOURNISSEUR | PRIX = NOMBRE | NOM | PROGRAM | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION = PROI_VERSION | PTC_WM_VERSION = PDMREV | PTC_WM_LOCATION | PTC_WM_CREATED_BY | PTC_WM_CREATED_ON | PTC_WM_MODIFIED_ON | MASSE_KG | VOLUME (m3) | AIRE | PTC_WM_NAME | PTC_WM_NUMBER | PTC_COMMON_NAME | MC_ERRORS
CS578-VIR-D23-EP7-6_5M_1 | virole Ø2300 EP 7 | CS578 | BEA | PRV_VIROLE_DV23 | FR | - | 0 | PIECE_DE_DEPART_FABIEN | no | B | 11 | B.11 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Viroles | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | 16-Feb-26 11:57:58 AM | 1077.11 | 494089000 | 125.363 | CS578-VIR-D23-EP7-6_5M.PRT | CS578-VIR-D23-EP7-6_5M.PRT | CS578-VIR-D23-EP7-6_5M.PRT | PTC_Identity Data - VOLUME_INTERIEUR: 2.10274; PROI_MODIFIED: 0; TULIPAGE: 1; Instance Property - IN_D_9: 4800
2 x SST-CS242-FB2300-RTM | FOND BOMBE 2300 | SST-CS242 | BEA | PRV | FR | - | 0 | - | no | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | Benoît AUDE (baude: simop) | 12-Jul-24 11:05:21 AM | 20-Jan-26 10:29:57 AM | 61.8024 | 39115500 | 7.84004 | A2300.22.066 | SST-CS242-FB2300-RTM.PRT | A2300.22.066 | 1 | PTC_Identity Data - SOUS_TITRE: RTM; NOM_PROJET: -; VERIFICATEUR: TERRE ENTIERE; TOLERANCES_GENERALES: ±1%; DATE: 17/06/2022; NUMPLAN: A2300.22.066
SST-CS750-TH-D750-PRV | TROU D'HOMME PRV Ø750 | SST-CS750 | BEA | PRV | FR | - | 0 | SST-CS-263-TUBE-D750 | no | K | 3 | K.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme | Benoît AUDE (baude: simop) | 07-Feb-23 09:35:19 AM | 20-Jan-26 10:29:57 AM | 6.60463 | 4180150 | 1.05795 | SST-CS750-TH-D750-PRV | SST-CS750-TH-D750-PRV.PRT | SST-CS750-TH-D750-PRV | PTC_Identity Data - SOUS_TITRE: LONGUEUR 1 M; VERIFICATEUR: EB; TOLERANCES_GENERALES: ±5mm; DATE: 19/09/2019; NUMPLAN: A2100.19.181; MASSE_GR: 6604.63; MFG_WP_MATERIAL: PRV
2 x MA101 | MANCHON DN100 M/F | MA101 |  | PVC |  |  |  | REDUCTION PVC 100/93 F/M ZTT |  | B | 8 | B.8 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Manch | Fabrice AIMARD (faimard: simop) | 08-Oct-15 04:35:07 PM | 16-Jan-24 03:51:03 PM | 0.120588 | 84921.2 | 0.0693907 | ma101.prt | MA101.PRT |  | 1 | PTC_Identity Data - MASSE: 0.000120588; IFC_EXPORT_TYPE: IsSelectedForExport_
2 x CU325-TAMPON-D600 | CORPS TAMPON A VISSER D600 | CU325 | G.THEBAULT | PEHD3850 | FR |  |  |  |  | D | 3 | D.3 | /Bibliothèques/Eléments Standards Internes/Accès voiries/Couvercle-Tampons/PE | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | 20-Jan-26 10:29:57 AM | 7.02098 | 7485060 | 1.45966 | cu325-tampon-d600.prt | CU325-TAMPON-D600.PRT |  | 2 | PTC_Identity Data - SOUS_TITRE: POUR SEPARATEUR HYDROCARBURES; VERIFICATEUR: Y.LEPRIEUR; DATE: 15/05/95; NUMPLAN: 21-95-044; MFG_WP_MATERIAL: PEHD3850; IFC_EXPORT_TYPE: IsSelectedForExport_
TU315-NF_TUBE_DN315_EVAC_NF_1 | TUBE PVC D. 315 NF | TU315-NF | BEA | PVC | FR | - | 0 | PIECE_DE_DEPART_FABIEN | no | A | 1 | A.1 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Benoît AUDE (baude: simop) | 18-Nov-19 04:12:51 PM | 11-Sep-25 11:15:15 AM | 6.91777 | 4906220 | 1.28921 | tu315-nf_tube_dn315_evac_nf.prt | TU315-NF_TUBE_DN315_EVAC_NF.PRT | tu315-nf_tube_dn315_evac_nf.prt | PTC_Identity Data - VOLUME_INTERIEUR: 0.0465283; PROI_MODIFIED: 0
TU315-NF_TUBE_DN315_EVAC_NF_2 | TUBE PVC D. 315 NF | TU315-NF | BEA | PVC | FR | - | 0 | PIECE_DE_DEPART_FABIEN | no | A | 1 | A.1 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Benoît AUDE (baude: simop) | 18-Nov-19 04:12:51 PM | 11-Sep-25 11:15:15 AM | 6.81296 | 4831880 | 1.2699 | tu315-nf_tube_dn315_evac_nf.prt | TU315-NF_TUBE_DN315_EVAC_NF.PRT | tu315-nf_tube_dn315_evac_nf.prt | PTC_Identity Data - VOLUME_INTERIEUR: 0.0458234; PROI_MODIFIED: 0

# IfcElementAssembly: General (3)
In: Default Storey
PTC_Identity Data - DESSINATEUR: BEA; VERIFICATEUR: SDLRB; DATE: 30/07/2019; LANGUE: FR; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PTC_MODIFIED: no; PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_CREATED_BY: Benoît AUDE (baude: simop); PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_MODIFIED_ON: 20-Jan-26 10:29:57 AM; PTC_ORGANIZATION_ID: SIMOP; CODE: -; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement; IFC_EXPORT_TYPE: IsSelectedForExport_
Name | TITRE | SOUS_TITRE | REFERENCE | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION = PROI_VERSION | PTC_WM_VERSION = PDMREV | PTC_WM_LOCATION | PTC_WM_CREATED_ON | MASSE_KG | VOLUME | AIRE | NUMPLAN | PTC_WM_NAME = PTC_COMMON_NAME | PTC_WM_NUMBER
THS750-TH-SIMPLIFIE-D750 | TROU D'HOMME Ø750 SIMPLIFIE | SANS FERMETURE | THS750 | K | 5 | K.5 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHS 750 | 22-Apr-22 08:50:42 AM | 7.00305 | 4461740 | 2.39456 | A2100.19.172 | A2100-19-172-THS750.ASM | THS750-TH-SIMPLIFIE-D750.ASM | PTC_Identity Data - TOLERANCES_GENERALES: ±5mm; PROJET: A DEFINIR DANS LES PARAMETRES; MC_ERRORS: 2
2 x KTHSF750-KIT-FERMETURE-R | KIT FERMETURE REHAUSSABLE THS Ø 750 | POUR TROU D'HOMME PRV Ø 750 SIMPLIFIE | KTHSF750R | C | 3 | C.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHSF DIAM | 06-May-21 03:06:59 PM | 9.32954 | 9660250 | 4.22595 | A2100.19.171 | A2100-19-171-KTHSF750.ASM | KTHSF750-KIT-FERMETURE-R.ASM
