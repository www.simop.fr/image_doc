Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: fte3-6318-55.ifc
Time: 2026-02-16T16:49:53
Author: faimard
Organization: BIMDeX
Written by: BIMDeX 25.0.0.1
Made in: BIMDeX

# IfcProject, Default Project
Description: Description of Default Project; Phase: Project Status
PTC_Identity Data - TITRE: FOSSE TOUTES EAUX 55 M3; SOUS_TITRE: DIAMETRE 2300; NOM_PROJET: 20 A 70 M3; DESSINATEUR: BEA; VERIFICATEUR: AL-ABAK; REFERENCE: FTE3-55; TOLERANCES_GENERALES: ±10mm; DATE: 02/07/2025; LANGUE: FR; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PROJET: FOSSES TOUTES EAUX HORIZONTALES; PTC_WM_REVISION: A; PTC_WM_ITERATION: 5; PTC_WM_VERSION: A.5; PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_LOCATION: /Produits/Produits R et D/Eaux usées/Assainissement non-collectif/Fosses toutes; PTC_WM_CREATED_BY: Benoît AUDE (baude: simop); PTC_WM_CREATED_ON: 02-Jul-25 11:40:58 AM; PTC_WM_MODIFIED_BY: Fabrice AIMARD (faimard: simop); PTC_WM_MODIFIED_ON: 16-Feb-26 04:33:52 PM; PTC_ORGANIZATION_ID: SIMOP; CODE: -; MASSE_KG: 2276.15; VOLUME: 986617000; AIRE: 420.258; NUMPLAN: A2200.25.054; VOLUME_FTE: 55.0281; SURMIR: 20.8585; PTC_MODIFIED: yes; PDMREV: A.5+; PDMRL: En cours de traitement; PROI_REVISION: A; PROI_VERSION: 5+; PROI_RELEASE: En cours de traitement; TITRE_HYDREAL: Fosse toutes eaux 55000 litres PRV; REFERENCE_HYDREAL: FRC55; PTC_WM_NAME: A2200.25.054; PTC_WM_NUMBER: FTE3-6318-55.ASM; VGRAISSE: 4.30535; REFERENCE_SIMOP: FTE3/6318/55; TITRE_SIMOP: FOSSE TOUTES EAUX PRV - 55 M3; PTC_COMMON_NAME: A2200.25.054

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Storey
In: Default Building
Description: Description of Default Building Storey

# IfcBuildingElementProxy: General (55)
In: Default Storey
PTC_Identity Data - PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_ORGANIZATION_ID: SIMOP; PTC_MODIFIED: no; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement
Name | TITRE | REFERENCE | DESSINATEUR | PTC_MATERIAL_NAME = PTC_MASTER_MATERIAL = PTC_REPORTED_MATERIAL | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION = PROI_VERSION | PTC_WM_VERSION = PDMREV | PTC_WM_LOCATION | PTC_WM_CREATED_BY | PTC_WM_CREATED_ON | PTC_WM_MODIFIED_BY | PTC_WM_MODIFIED_ON | MASSE_KG | VOLUME (m3) | AIRE | PTC_WM_NAME | PTC_WM_NUMBER | PTC_COMMON_NAME | IFC_EXPORT_TYPE
CS578-VIROLE-D23-EP7-15M_1 | virole Ø2300 EP 7 | CS578 | BEA | PRV_VIROLE_DV23 | B | 10 | B.10 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Viroles | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 16-Feb-26 11:57:58 AM | 1905.95 | 874290000 | 190.446 | CS578-VIROLE-D2300-EP7.PRT_INST | CS578-VIROLE-D23-EP7-15M.PRT | CS578-VIROLE-D2300-EP7.PRT_INST | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 2.10274; PROI_MODIFIED: 0; TULIPAGE: 1; Instance Property - IN_D_9: 13220; IN_D_27: -6610; IN_D_28: 1300; IN_D_39: -4406.67
SST-CS242-FB2300-RTM_1 | FOND BOMBE 2300 | SST-CS242 | BEA | PRV | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | Benoît AUDE (baude: simop) | 12-Jul-24 11:05:21 AM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 61.8024 | 39115500 | 7.84004 | A2300.22.066 | SST-CS242-FB2300-RTM.PRT | A2300.22.066 | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: -; PROGRAM: no; NOMBRE: 0; SOUS_TITRE: RTM; NOM_PROJET: -; VERIFICATEUR: TERRE ENTIERE; TOLERANCES_GENERALES: ±1%; DATE: 17/06/2022; NUMPLAN: A2300.22.066; MC_ERRORS: 1
SST-CS242-FB2300-RTM_2 | FOND BOMBE 2300 | SST-CS242 | BEA | PRV | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | Benoît AUDE (baude: simop) | 12-Jul-24 11:05:21 AM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 61.8024 | 39115500 | 7.84004 | A2300.22.066 | SST-CS242-FB2300-RTM.PRT | A2300.22.066 | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: -; PROGRAM: no; NOMBRE: 0; SOUS_TITRE: RTM; NOM_PROJET: -; VERIFICATEUR: TERRE ENTIERE; TOLERANCES_GENERALES: ±1%; DATE: 17/06/2022; NUMPLAN: A2300.22.066; MC_ERRORS: 1
2 x SP7390-ANNEAU-CMU3T-M22 | ANNEAU DE LEVAGE CMU 3T M22 | SP7390 | BEA | ACIER | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Eléments de manutention/Anneaux | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.161597 | 20640.8 | 0.00470763 | SP7388-ANNEAU-CMU4T-M24.PRT_INST | SP7390-ANNEAU-CMU3T-M22.PRT | SP7388-ANNEAU-CMU4T-M24.PRT_INST | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: GODET; PRIX: 0; NOM: ANNEAU DE LEVAGE CMU 3T M22; PROGRAM: no; NOMBRE: 0; SOUS_TITRE: ANNEAU DE LEVAGE CMU 3T M22; NOM_PROJET: LEVAGE; VERIFICATEUR: BEA; TOLERANCES_GENERALES: DIN580; DATE: 16/03/2016; MC_ERRORS: 1; DIAMETRE_AFFICHE: 90; DIAMETRE_REEL: 44; REF_FOURNISSEUR: ALMAL522
2 x SST-CS750-TH-D750-PRV | TROU D'HOMME PRV Ø750 | SST-CS750 | BEA | PRV | K | 3 | K.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme | Benoît AUDE (baude: simop) | 07-Feb-23 09:35:19 AM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 6.60463 | 4180150 | 1.05795 | SST-CS750-TH-D750-PRV | SST-CS750-TH-D750-PRV.PRT | SST-CS750-TH-D750-PRV | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: SST-CS-263-TUBE-D750; PROGRAM: no; NOMBRE: 0; SOUS_TITRE: LONGUEUR 1 M; VERIFICATEUR: EB; TOLERANCES_GENERALES: ±5mm; DATE: 19/09/2019; NUMPLAN: A2100.19.181; MASSE_GR: 6604.63; MFG_WP_MATERIAL: PRV
4 x JS100 | CRS JOINT SIMOP D100 QUALITE HYDRO | JS100 |  | NITRILE | J | 1 | J.1 | /Bibliothèques/Eléments Standards Internes/Etanchéité/Joint-JS | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.0526939 | 35846.2 | 0.0230789 | js100.prt | JS100.PRT | js100.prt | IsSelectedForExport_ | PTC_Identity Data - MC_ERRORS: 3
4 x MA101 | MANCHON DN100 M/F | MA101 |  | PVC | B | 8 | B.8 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Manch | Fabrice AIMARD (faimard: simop) | 08-Oct-15 04:35:07 PM | Fabrice AIMARD (faimard: simop) | 16-Jan-24 03:51:03 PM | 0.120588 | 84921.2 | 0.0693907 | ma101.prt | MA101.PRT |  | IsSelectedForExport_ | PTC_Identity Data - NOM: REDUCTION PVC 100/93 F/M ZTT; MC_ERRORS: 1; MASSE: 0.000120588
4 x AD032 | BOUCHON PROTECTION 600 B990 Ø100 | AD032 |  | PVC | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Bouchons de protection | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.0170822 | 12115.1 | 0.0314718 | ad032.prt | AD032.PRT | ad032.prt | IsSelectedForExport_ | PTC_Identity Data - NOM: BOUCHON PROTECTION 600 B990 Ø100; MASSE: 0.00002044; DESSINE_PAR: BA; DESIGNATION: BOUCHON PROTECTION 600 B990 Ø100; SURFACE: 90604.4; MATIERE: Polyester
2 x GRAVPL02-STANDARD-MONT_INST | PLAQUE IDENTIFICATION PRODUIT | PLIP | BEA | PEHD3850 | A | 3 | A.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV | Benoît AUDE (baude: simop) | 31-Mar-22 10:14:50 AM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.0144636 | 15419.6 | 0.0151018 | gravpl02-standard-montage.prt_INST | GRAVPL02-STANDARD-MONT_INST.PRT | gravpl02-standard-montage.prt_INST | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: A DEFINIR DANS LES PARAMETRES; PROGRAM: no; NOMBRE: 0; NOM_PROJET: BIOXYMOP MAX; VERIFICATEUR: SDRB; TOLERANCES_GENERALES: ISO 2768 - mk; DATE: 27/07/2020; NUMPLAN: A2300.20.109; MC_ERRORS: 1
4 x BV103-I | VIS INOX A2 3X20 TETE FRAISSEE FENDUE | BV103-I |  | 304 | A | 6 | A.6 | /Bibliothèques/Eléments Standards/Eléments de fixations/Vis | Benoît AUDE (baude: simop) | 17-Apr-13 11:45:05 AM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.0016128 | 204.152 | 0.000140808 | bv103-i.prt | BV103-I.PRT |  | IsSelectedForExport_
2 x JOINT-PLAT-KTHSF_750 | JOINT NITRILE D10/12 Rlx30M | JOC10/12 |  | NITRILE | B | 2 | B.2 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHSF DIAM | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.337124 | 229336 | 0.114668 | joint-plat-kthsf_750.prt | JOINT-PLAT-KTHSF_750.PRT | joint-plat-kthsf_750.prt | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; PROGRAM: no; NOMBRE: 0; MC_ERRORS: 1
2 x CU371-COLLET-D600 | CORPS COLLET D.600 BLAISE | CU371 |  | PEHD3850 | B | 1 | B.1 | /Bibliothèques/Eléments Standards Internes/Accès voiries/Collets | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 1.65204 | 1761230 | 0.556555 | CU371-COLLET-D600.prt | CU371-COLLET-D600.PRT |  | IsSelectedForExport_
2 x JOC10_12-JOINT-NITRILE-KTHSF750 | JOINT TORIQUE DIAM.12 L1520 | AD203-1 |  | NITRILE | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Etanchéité/Joint-kthsf | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 0.260424 | 177159 | 0.0708638 | joc10_12-joint-nitrile-kthsf750.prt | JOC10_12-JOINT-NITRILE-KTHSF750.PRT | joc10_12-joint-nitrile-kthsf750.prt | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; PROGRAM: no; NOMBRE: 0; MC_ERRORS: 1
2 x CU325-TAMPON-D600 | CORPS TAMPON A VISSER D600 | CU325 | G.THEBAULT | PEHD3850 | D | 3 | D.3 | /Bibliothèques/Eléments Standards Internes/Accès voiries/Couvercle-Tampons/PE | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 7.02098 | 7485060 | 1.45966 | cu325-tampon-d600.prt | CU325-TAMPON-D600.PRT |  | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; SOUS_TITRE: POUR SEPARATEUR HYDROCARBURES; VERIFICATEUR: Y.LEPRIEUR; DATE: 15/05/95; NUMPLAN: 21-95-044; MC_ERRORS: 2; MFG_WP_MATERIAL: PEHD3850
16 x FCV051-RIVET-AGRAPHE-4_8-30 | RIVET AGRAPHE 4.8x30 | FCV051 | BIBLIOTHECAIRE | 304 | B | 1 | B.1 | /Bibliothèques/Eléments Standards/Eléments de fixations/Rivets | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.00737099 | 933.036 | 0.000499301 | fcv051-rivet-agraphe-4_8-30.prt | FCV051-RIVET-AGRAPHE-4_8-30.PRT | fcv051-rivet-agraphe-4_8-30.prt | IsSelectedForExport_ | PTC_Identity Data - VERIFICATEUR: AUGUSTYN; MASSE: 0.0001137; DESIGNATION: -; MATIERE: AGS; DATE_DESS: -; PROTECTION: -; NGPAO: -; ASPECT: -; ETSURF: -; EFFECTUE_PAR: -; UNITE: UNITAIRE; VISSERIE: yes; OLD_BASE: yes
TU160-NF_TUBE_DN160_EVAC_NF_1 | TUBE PVC D. 160 NF | TU160-NF | BEA | PVC | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 2.66714 | 1891590 | 1.1854 | tu160-nf_tube_dn160_evac_nf.prt | TU160-NF_TUBE_DN160_EVAC_NF.PRT | tu160-nf_tube_dn160_evac_nf.prt | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 0.00185299; MC_ERRORS: 1
2 x JOINT-FORSHEDA-D160 | Joint F570 D250 NBR | AD656-160 |  | NBR | A | 1 | A.1 | /Bibliothèques/Eléments Standards/Etanchéité/Joint-Forsheda | Baptiste LEFRANC (Supprimé) | 06-May-21 02:48:11 PM | Baptiste LEFRANC (Supprimé) | 30-Jul-21 03:12:49 PM | 1.28377 | 1027020 | 0.0775857 | joint-forsheda-d160 | JOINT-FORSHEDA-D160 | PTC_Identity Data - MFG_WP_MATERIAL: NBR; MASSE: 0.00128377; DESSINE_PAR: ghg; SURFACE: 90604.4; MATIERE: Polyester
TU160-NF_TUBE_DN160_EVAC_NF_2 | TUBE PVC D. 160 NF | TU160-NF | BEA | PVC | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Tubes | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 1.66696 | 1182240 | 0.742055 | tu160-nf_tube_dn160_evac_nf.prt | TU160-NF_TUBE_DN160_EVAC_NF.PRT | tu160-nf_tube_dn160_evac_nf.prt | IsSelectedForExport_ | PTC_Identity Data - LANGUE: FR; FOURNISSEUR: -; PRIX: 0; NOM: PIECE_DE_DEPART_FABIEN; PROGRAM: no; NOMBRE: 0; VOLUME_INTERIEUR: 0.00185299; MC_ERRORS: 1
2 x MA160_MANCHON-PVC-D160 | MANCHON PVC DIAM.160 | MA160 |  | PVC | B | 2 | B.2 | /Bibliothèques/Eléments Standards/Eléments de canalisations/PVC-Ecoulement/Manch | Benoît AUDE (baude: simop) | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 22-Apr-22 03:32:42 PM | 0.481321 | 341362 | 0.192813 | MA160_MANCHON-PVC-D160.PRT | MA160_MANCHON-PVC-D160.PRT | MA160_MANCHON-PVC-D160.PRT | IsSelectedForExport_ | PTC_Identity Data - NOM: MANCHON PVC DIAM.160; PTC_PP_MODIFIED_ON: 25-Mar-11 03:03:42 PM; PTC_PP_VERSION: -.4; PTC_PP_REVISION: -; PTC_PP_ITERATION: 4; PTC_PP_RELEASE_STATE: En cours; PTC_PP_MODIFIED_BY: Fabrice AIMARD; PTC_PP_LOCATION: /Catalog/Parts/Travail ProENGINEER/Eléments-Canalisations/PVC-Ecoulement/Manchon; PTC_PP_CREATED_BY: Boris AMIOT; PTC_PP_OWNER: Boris AMIOT; PTC_PP_CREATED_ON: 06-Jan-11 12:43:26 PM

# IfcElementAssembly: General (6)
In: Default Storey
PTC_Identity Data - DESSINATEUR: BEA; LANGUE: FR; CLIENT: -; INDICE: A; FOURNISSEUR: Voir détails; PRIX: 0; PTC_MODIFIED: no; PTC_WM_LIFECYCLE_STATE: En cours de traitement; PTC_WM_LIFECYCLE: EPMDoc_Lifecycle; PTC_WM_CREATED_BY: Benoît AUDE (baude: simop); PTC_ORGANIZATION_ID: SIMOP; CODE: -; PDMRL: En cours de traitement; PROI_RELEASE: En cours de traitement
Name | TITRE | SOUS_TITRE | VERIFICATEUR | REFERENCE | TOLERANCES_GENERALES | DATE | PROJET | PTC_WM_REVISION = PROI_REVISION | PTC_WM_ITERATION = PROI_VERSION | PTC_WM_VERSION = PDMREV | PTC_WM_LOCATION | PTC_WM_CREATED_ON | PTC_WM_MODIFIED_BY | PTC_WM_MODIFIED_ON | MASSE_KG | VOLUME | AIRE | NUMPLAN | PTC_WM_NAME = PTC_COMMON_NAME | PTC_WM_NUMBER | IFC_EXPORT_TYPE
SST-CS242-FB-D2300-RTM-AVEC-VOL_1 | FOND BOMBE RTM DIAM 2300 | DIAM 2300 EPAISSEUR 7 mm | AL-BPM | SST-CS242 | ± 10 mm | 17/06/2022 | - | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | 16-Jun-25 01:55:24 PM | Benoît AUDE (baude: simop) | 20-Jan-26 01:48:49 PM | 61.8281 | 39115500 | 29.838 | A2300.22.066 | A2300.22.066 | SST-CS242-FB-D2300-RTM-AVEC-VOL.ASM | PTC_Identity Data - NOM_PROJET: POUR VIROLE Ø2300; VOLUMEFOND: 2.38519; SURFACEMIROIRFOND: 0.900038
SST-CS242-FB-D2300-RTM-AVEC-VOL_2 | FOND BOMBE RTM DIAM 2300 | DIAM 2300 EPAISSEUR 7 mm | AL-BPM | SST-CS242 | ± 10 mm | 17/06/2022 | - | A | 7 | A.7 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Fond Bombé/RTM | 16-Jun-25 01:55:24 PM | Benoît AUDE (baude: simop) | 20-Jan-26 01:48:49 PM | 61.8281 | 39115500 | 29.838 | A2300.22.066 | A2300.22.066 | SST-CS242-FB-D2300-RTM-AVEC-VOL.ASM | PTC_Identity Data - NOM_PROJET: POUR VIROLE Ø2300; VOLUMEFOND: 2.38519; SURFACEMIROIRFOND: 0.900038
2 x THS750-TH-SIMPLIFIE-D750 | TROU D'HOMME Ø750 SIMPLIFIE | SANS FERMETURE | SDLRB | THS750 | ±5mm | 30/07/2019 | A DEFINIR DANS LES PARAMETRES | K | 5 | K.5 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHS 750 | 22-Apr-22 08:50:42 AM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 7.00305 | 4461740 | 2.39456 | A2100.19.172 | A2100-19-172-THS750.ASM | THS750-TH-SIMPLIFIE-D750.ASM | IsSelectedForExport_ | PTC_Identity Data - MC_ERRORS: 2
2 x KTHSF750-KIT-FERMETURE-R | KIT FERMETURE REHAUSSABLE THS Ø 750 | POUR TROU D'HOMME PRV Ø 750 SIMPLIFIE | SDLRB | KTHSF750R |  | 30/07/2019 |  | C | 3 | C.3 | /Bibliothèques/Eléments Standards Internes/Standard PRV/Trous d'homme/KTHSF DIAM | 06-May-21 03:06:59 PM | Fabrice AIMARD (faimard: simop) | 20-Jan-26 10:29:57 AM | 9.32954 | 9660250 | 4.22595 | A2100.19.171 | A2100-19-171-KTHSF750.ASM | KTHSF750-KIT-FERMETURE-R.ASM | IsSelectedForExport_
